## meta-nuc-bios/recipes-bsp/coreboot/files/mainboard/Kconfig.name
```kconfig
# SPDX-License-Identifier: GPL-2.0-or-later

config BOARD_INTEL_NUC5I5RYB
	bool "NUC5i5RYB"
```
